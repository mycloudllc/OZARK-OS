FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-QPulseAudioInput-don-t-wait-forever-on-a-stream-that.patch"
